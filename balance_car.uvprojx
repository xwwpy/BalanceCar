# Keil uVision project balance_car.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Start;.\User;.\Libraries;.\System;.\oled;.\math;.\stm32f103_m_Exit;.\stm32f103_m_IIC;.\stm32f103_m_spi;.\w25q64;.\stmf103_m_timer;.\test;.\Button
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Libraries
    ./Libraries/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h car_bat.c car_bat.h car_usart2.c car_usart2.h car_button.c car_button.h car_pwm.c car_pwm.h car_encoder.c car_encoder.h
  group System
    ./System/: Delay.c Delay.h
  group oled
    ./oled/: oled.c oled.h
  group math
    ./math/: math_utils.c math_utils.h
  group stm32f103_m_Exit
    ./stm32f103_m_Exit/: exit.c exit.h
  group stm32f103_m_IIC
    ./stm32f103_m_IIC/: IIC.c IIC.h
  group spi
    ./stm32f103_m_spi/: spi.c spi.h
  group w25q64
    ./w25q64/: w25q64.c w25q64.h
  group stm32f103_m_timer
    ./stmf103_m_timer/: timer.c timer.h
  group test
    ./test/: car_bat_test.c car_bat_test.h car_encoder_test.c car_encoder_test.h car_measure_method_m_test.c car_measure_method_m_test.h
  group button
    ./Button/: button_utils.c button_utils.h
